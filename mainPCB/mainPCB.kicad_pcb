# Repository frowin/baristaWatch

File README.md:

# baristaWatch
baristaWatch is a framework for enabling IoT on portafilter machines

The project website is https://baristaWatch.com

## KiCad design mainPCB/mainPCB.kicad_pcb

Parts:
C1: 2.2uF; CP_Radial_D8.0mm_P3.50mm
C_5V_relais1: 2.2uF; CP_Radial_D8.0mm_P3.50mm
DHT22_R1: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
EN_R1: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
H1_5V_IN1: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
H2_UART1, H5_RGBLED1, H11_ANATEMP1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
H3_PUMPREL1, H4_DHT22, H7_SCALE1, H9_WATER1, H10_PUMP1: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
H6_DISP1: Conn_01x10_Male; PinHeader_1x10_P2.54mm_Vertical
H8_ROTA1: Conn_01x05_Male; PinHeader_1x05_P2.54mm_Vertical
H12_SD1: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
H13_BLANK1: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
H_3V3, H_5V1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
H_5V_IN1: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
H_ENABLE1: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
H_GND1: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
H_LED_3V3, H_LED_5V1: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
MAX1, MAX2: MAX31865
R_3V3_ind1, R_5V_ind1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: ESP32-DEVKITC-32D; MODULE_ESP32-DEVKITC-32D; PARTREV 4

Connections:
+3V3: DHT22_R1.1, EN_R1.1, H4_DHT22.1, H6_DISP1.1, H7_SCALE1.1, H8_ROTA1.1, H9_WATER1.1, H10_PUMP1.1, H11_ANATEMP1.1, H12_SD1.1, H13_BLANK1.1, H_5V1.1, H_5V1.2, H_5V1.3, H_5V1.4, MAX1.6, MAX2.6, R_3V3_ind1.1, U1.1 (3V3)
+5V: C_5V_relais1.1, H1_5V_IN1.1, H2_UART1.1, H3_PUMPREL1.1, H_3V3.1, H_3V3.2, H_3V3.3, H_3V3.4, H_5V_IN1.1, R_5V_ind1.1
/DHT22: DHT22_R1.2, H4_DHT22.2, U1.32 (IO4)
/EN: C1.1, EN_R1.2, H_ENABLE1.2, U1.2 (EN)
/LED_GREEN: H5_RGBLED1.2, U1.35 (IO15)
/LED_RED_BLANK2: H5_RGBLED1.1, H13_BLANK1.3, U1.12 (IO14)
/PHOTO_IN: H6_DISP1.7, U1.3 (SENSOR_VP)
/PUMP_IN: H10_PUMP1.2, U1.6 (IO35)
/ROTARY_CLK_PUMP_RELAIS: H3_PUMPREL1.2, H8_ROTA1.2, U1.7 (IO32)
/ROTARY_DT_LED_BLUE: H5_RGBLED1.3, H8_ROTA1.3, U1.9 (IO25)
/ROTARY_SW_ANALOG_T2: H8_ROTA1.4, H11_ANATEMP1.3, U1.5 (IO34)
/ROTARY_SW_BLANK4: H13_BLANK1.5
/SCALE_DT_ANALOG_T1: H7_SCALE1.2, H11_ANATEMP1.2, U1.8 (IO33)
/SCALE_DT_BLANK3: H13_BLANK1.4
/SPI_CLK: H6_DISP1.5, H12_SD1.5, MAX1.5, MAX2.5, U1.28 (IO18)
/SPI_CS_OLED: H6_DISP1.3, U1.15 (IO13)
/SPI_CS_SD_BLANK1: H12_SD1.3, H13_BLANK1.2, U1.29 (IO5)
/SPI_CS_TEMP1: MAX1.2, U1.25 (IO21)
/SPI_CS_TEMP2: MAX2.2, U1.22 (IO22)
/SPI_DC: H6_DISP1.6, H12_SD1.6, U1.13 (IO12)
/SPI_MISO: H12_SD1.7, MAX1.4, MAX2.4, U1.27 (IO19)
/SPI_MOSI: H6_DISP1.4, H12_SD1.4, MAX1.3, MAX2.3, U1.21 (IO23)
/SPI_RES: H6_DISP1.2, H12_SD1.2, U1.34 (IO2)
/TLC_CLK: H6_DISP1.9, U1.11 (IO27)
/TLC_DATA: H6_DISP1.8, U1.10 (IO26)
/UART2_RX: H2_UART1.3, U1.31 (IO16)
/UART2_TX: H2_UART1.2, U1.30 (IO17)
/V_IN: H_5V_IN1.2, U1.19 (EXT_5V)
/WATER_IN: H9_WATER1.2, U1.4 (SENSOR_VN)
GND: C1.2, C_5V_relais1.2, H1_5V_IN1.2, H2_UART1.4, H3_PUMPREL1.3, H4_DHT22.3, H5_RGBLED1.4, H6_DISP1.10, H7_SCALE1.3, H8_ROTA1.5, H9_WATER1.3, H10_PUMP1.3, H11_ANATEMP1.4, H12_SD1.8, H13_BLANK1.6, H_ENABLE1.1, H_GND1.1, H_GND1.2, H_GND1.3, H_GND1.4, H_LED_3V3.2, H_LED_5V1.2, MAX1.7, MAX2.7, U1.20 (GND3)
unnamed: H_LED_3V3.1, R_3V3_ind1.2
unnamed: H_LED_5V1.1, R_5V_ind1.2

Notes on the sheet:
HEADER 1 +5V power input
HEADER 2 UART
HEADER 3 relais output
HEADER 4 DHT22
HEADER 5 RGB LED
HEADER 6 display
HEADER 7 scale
HEADER 8 rotary encoder
HEADER 9 water sensor
HEADER 10 pump in
HEADER 11 analog temp in
HEADER 12 sd card
HEADER +5V
HEADER +3V3
HEADER GND
+5V indicator LED
+3V3 indicator LED
HEADER 13 BLANK general purpose

Board: 2 copper layers, 100.0 x 100.0 mm, 33 parts (0 on the bottom side), 30 nets.

Other parts of the board:
M3, M3#2, M3#3, M3#4: MountingHole_3.2mm_M3

## Commit log

2022-01-13 added code and pcb
